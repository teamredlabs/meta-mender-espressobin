require recipes-bsp/u-boot/u-boot-fw-utils-mender.inc
require u-boot-espressobin.inc
