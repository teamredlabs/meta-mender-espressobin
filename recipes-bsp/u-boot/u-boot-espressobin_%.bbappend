inherit mender-uboot

require recipes-bsp/u-boot/u-boot-mender.inc
require u-boot-espressobin.inc
